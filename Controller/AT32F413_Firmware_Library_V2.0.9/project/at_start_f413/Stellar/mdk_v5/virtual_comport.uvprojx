# Keil uVision project virtual_comport.uvprojx, settings and files
target virtual_comport (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: AT32F413RC ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: virtual_comport +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F413RCT7,USE_STDPERIPH_DRIVER,AT_START_F413_STELLAR_GATEWAY_V1
  c include: ..\inc;..\..\..\at32f413_board;..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\middlewares\usbd_drivers\inc;..\..\..\..\middlewares\usbd_class\cdc;..\..\..\..\..\..\share;..\..\..\..\..\..\common\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: at32f413_clock.c at32f413_int.c main.c usb_if.c usart_if.c spi_if.c in612_ctrl.c gw_mng.c
    ../../../../../../common/util/: rq.c
  group bsp
    ../../../at32f413_board/: at32f413_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32f413_acc.c at32f413_crm.c at32f413_exint.c at32f413_flash.c at32f413_gpio.c at32f413_misc.c at32f413_pwc.c at32f413_usart.c at32f413_usb.c at32f413_dma.c at32f413_spi.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f413.c
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f413.s
  group usbd_drivers
    ../../../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../../middlewares/usbd_class/cdc/: cdc_class.c cdc_desc.c
  group readme
    ../: readme.txt
